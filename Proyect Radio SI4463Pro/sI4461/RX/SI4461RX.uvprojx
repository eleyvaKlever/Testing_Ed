# Keil uVision project SI4461RX.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: EFM32TG110F32 Energy Micro
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SI4461RX
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: hardware.s lcd.s main.s si4461.s startup.s TG110F32.inc
software components: CMSIS:CORE 3.30.0
